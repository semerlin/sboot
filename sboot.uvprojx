# Keil uVision project sboot.uvprojx, settings and files
target sboot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sboot +hex
  AfterMake: fromelf --bin --output .\Objects\sboot.bin .\Objects\sboot.axf
  AfterMake: D:\project\sboot\copy_sboot.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, __ENABLE_TRACE, __DEBUG, USE_FULL_ASSERT
  c include: .\cmsis;.\fwlib\inc;.\sboot
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cmsis
    ./cmsis/: core_cm3.c system_stm32f10x.c
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group sboot
    ./sboot/: main.c stm32f10x_it.c startup_stm32f10x.s dbg.c sboot.c crc32.c upgrade_flash.c
